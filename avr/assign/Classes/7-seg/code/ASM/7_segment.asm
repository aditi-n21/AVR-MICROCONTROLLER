;WAP to display value from 0 to 9 with a proper delay.


	$MOD51
	ORG 00H
AG:	MOV	P1,#0C0H
	ACALL	DELAY
	MOV	P1,#0F9H
	ACALL	DELAY
	MOV	P1,#0A4H
	ACALL	DELAY
	MOV	P1,#0B0H
	ACALL	DELAY
	MOV	P1,#99H
	ACALL	DELAY
	MOV	P1,#92H
	ACALL	DELAY
	MOV	P1,#82H
	ACALL	DELAY
	MOV	P1,#0F8H
	ACALL	DELAY
	MOV	P1,#80H
	ACALL	DELAY
	MOV	P1,#98H
	ACALL	DELAY
	SJMP	AG

DELAY:
	MOV	R1,#25
L3:	MOV	R2,#255
L2:	MOV	R3,#255
L1:	DJNZ	R3,L1
	DJNZ	R2,L2
	DJNZ	R1,L3
	RET
	END
